# IAR project Rover-Coin-Game.ewp, settings and files
configuration Rover-Coin-Game (ARM, debug)
  General.OGChipSelectEditMenu: STM32L432KC ST STM32L432KC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L432xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Modules\displayST7735; ..\Modules\roverGame; ..\Modules\background; ..\Modules\joystick; ..\Modules\generic_game; ..\Modules\roverGame\game_obj; ..\Modules\roverGame\rover_math
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Rover-Coin-Game.hex
  ILINK.IlinkOutputFile: Rover-Coin-Game.out
  ILINK.IlinkIcfFile: stm32l432xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l432xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/User/Modules/background
    ../Modules/background/: background.c
  group Application/User/Modules/displayST7735
    ../Modules/displayST7735/: displayST7735.c font8x8_basic.h
  group Application/User/Modules/generic_game
    ../Modules/generic_game/: generic_game.c
  group Application/User/Modules/joystick
    ../Modules/joystick/: joystick.c
  group Application/User/Modules/roverGame
    ../Modules/roverGame/: rover_game.c
  group Application/User/Modules/roverGame/game_obj
    ../Modules/roverGame/game_obj/: coin_obj.c rover_obj.c
  group Application/User/Modules/roverGame/rover_math
    ../Modules/roverGame/rover_math/: rover_math.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
